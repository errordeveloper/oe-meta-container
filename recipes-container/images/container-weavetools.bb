PACKAGE_INSTALL = "ethtool conntrack-tools curl"

require container-base.inc
