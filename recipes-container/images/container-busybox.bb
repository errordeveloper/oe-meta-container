PACKAGE_INSTALL = "busybox"

require container-base.inc
