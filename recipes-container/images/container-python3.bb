PACKAGE_INSTALL = "bash coreutils findutils sed grep gawk python3-core python3-modules libstdc++"

require container-base.inc
