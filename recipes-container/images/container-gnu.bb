LICENSE = "MIT"

IMAGE_FEATURES = ""
IMAGE_LINGUAS = ""
PACKAGE_INSTALL = "bash coreutils findutils sed grep gawk"

inherit core-image
