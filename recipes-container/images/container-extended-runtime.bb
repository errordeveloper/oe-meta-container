PACKAGE_INSTALL = "bash coreutils findutils sed grep gawk tar xz gzip bzip2 curl"

require container-base.inc
